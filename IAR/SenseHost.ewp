# IAR project SenseHost.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207C8 STM8S207C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207
  ICCSTM8.CCIncludePath2: ..\; ..\..\STM8S_StdPeriph_Lib\Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: SenseHost.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group delay
    ../: delay.c delay.h
  group flash_eeprom
    ../: flash.c flash.h
  group Gas Lighting
    ../: gas_lighting.c gas_lighting.h
  group packet
    ../: packet.c packet.h
  group RS485
    ../: rs485.c rs485.h
  group StdLib/inc
    ../../STM8S_StdPeriph_Lib/Libraries/STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_tim5.h stm8s_tim6.h stm8s_uart1.h stm8s_uart2.h stm8s_uart3.h stm8s_uart4.h stm8s_wwdg.h
  group StdLib/src
    ../../STM8S_StdPeriph_Lib/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart1.c stm8s_uart3.c stm8s_wwdg.c
  group System
    ../: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group Temperature
    ../: DallasTemperature.c DallasTemperature.h one_wire.c one_wire.h
  group uart
    ../: uart.c uart.h
